# Keil uVision project iot.uvprojx, settings and files
target wifi-node (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: firmware +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\inc;.\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group src
    ./src/: main.c uart.c sys-tick.c dht11.c gpio.c bh1750.c i2c.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
